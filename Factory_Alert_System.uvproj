# Keil uVision project Factory_Alert_System.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000E7FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source
    ./: LCD.c Factory_Alert_System.c
  group Configuration
    ./: RTX_Config.c LPC2300.s
  group Documentation
    ./: Abstract.txt
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
